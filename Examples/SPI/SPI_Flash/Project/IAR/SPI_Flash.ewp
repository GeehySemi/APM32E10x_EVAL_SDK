# IAR project SPI_Flash.ewp, settings and files
configuration APM32E103 (ARM, debug)
  General.OGChipSelectEditMenu: APM32E103ZE Geehy APM32E103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32E103_EVAL; APM32E10x
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Boards; ..\..\..\..\..\Boards\Board_APM32E103_EVAL\inc; ..\..\..\..\..\Libraries\APM32E10x_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\Device\Geehy\APM32E10x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_Flash.srec
  ILINK.IlinkOutputFile: SPI_Flash.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Geehy\apm32e103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32e10x_int.c main.c
  group Boards
    ../../../../../Boards/: Board.c
    ../../../../../Boards/Board_APM32E103_EVAL/src/: bsp_delay.c bsp_key.c bsp_lcd.c bsp_w25q16.c
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32E10x/Source/iar/: startup_apm32e10x_hd.s
    ../../Source/: system_apm32e10x.c
  group StdPeriphDriver
    ../../../../../Libraries/APM32E10x_StdPeriphDriver/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_smc.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_wwdt.c
