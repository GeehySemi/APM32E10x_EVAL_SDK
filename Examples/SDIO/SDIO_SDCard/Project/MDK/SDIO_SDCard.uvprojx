# Keil uVision project SDIO_SDCard.uvprojx, settings and files
target APM32E103_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32E103ZE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SDIO_SDCard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32E10X_HD,APM32E103_EVAL
  c include: ..\..\..\..\..\Libraries\APM32E10x_StdPeriphDriver\inc;..\..\..\..\..\Libraries\Device\Geehy\APM32E10x\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Boards\Board_APM32E103_EVAL\inc;..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\Middlewares\fat_fs\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../Source/: system_apm32e10x.c
    ../../../../../Libraries/Device/Geehy/APM32E10x/Source/arm/: startup_apm32e10x_hd.s
  group StdPeriphDriver
    ../../../../../Libraries/APM32E10x_StdPeriphDriver/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_smc.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_wwdt.c
  group Boards
    ../../../../../Boards/: Board.c
  group Application
    ../../Source/: main.c apm32e10x_int.c
  group Bsp
    ../../../../../Boards/Board_APM32E103_EVAL/src/: bsp_delay.c bsp_key.c bsp_sdio.c bsp_lcd.c
  group fatFs
    ../../../../../Middlewares/fat_fs/source/: diskio.c ff.c ffsystem.c ffunicode.c
